# Keil uVision project combination_lock_sala.uvprojx, settings and files
target Target 1 (6110000::V6.11::.\ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: projekt
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: LCD_ILI9325
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./src/: asciiLib.c interface_LCD.c LCD_ILI9325.c main.c Open1768_LCD.c touchscreen_LCD.c TP_Open1768.c UART.c
    ./include/: asciiLib.h interface_LCD.h LCD_ILI9325.h Open1768_LCD.h touchscreen_LCD.h TP_Open1768.h UART.h
software components: CMSIS:CORE 5.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
